# Keil uVision project template.uvprojx, settings and files
target debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC824M201JDH20 NXP
  pack: Keil.LPC800_DFP.1.2.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: img_keil_template +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: AM_VDEBUG
  c include: ..\..\..\ametal\CMSIS\Include;..\..\..\ametal\common\include;.\user_code;.\user_config;..\..\..\ametal\lpc82x\drivers\include;..\..\..\ametal\lpc82x\hw\include;..\..\..\ametal\lpc82x;.\board
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group common
    ../../../ametal/common/source/: am_i2c.c am_spi.c am_uart.c am_uart_int.c am_adc.c am_buzzer_pwm.c am_dac.c am_led.c am_wait.c am_softimer.c am_vdebug.c am_vfprintf_do.c am_vsnprintf.c am_kprintf.c am_jobq.c am_koutput.c am_snprintf.c am_rngbuf.c am_uart_rngbuf.c am_zm516x.c
  group startup
    ./startup/: am_startup_armcc_lpc82x.s
  group board
    ./board/: am_board.c am_delay.c
  group drivers
    ../../../ametal/lpc82x/drivers/source/: am_lpc82x_adc.c am_lpc82x_clk.c am_lpc82x_crc.c am_lpc82x_dma.c am_lpc82x_gpio.c am_lpc82x_i2c.c am_lpc82x_int.c am_lpc82x_mrt.c am_lpc82x_sct.c am_lpc82x_sct_cap.c am_lpc82x_sct_pwm.c am_lpc82x_sct_timing.c am_lpc82x_spi.c am_lpc82x_systick.c am_lpc82x_usart.c am_lpc82x_wkt.c am_lpc82x_wwdt.c
  group hw
    ../../../ametal/lpc82x/hw/source/: amhw_lpc82x_adc.c amhw_lpc82x_clk.c amhw_lpc82x_crc.c amhw_lpc82x_iap.c amhw_lpc82x_iocon.c amhw_lpc82x_pint.c amhw_lpc82x_sct.c amhw_lpc82x_swm.c amhw_lpc82x_usart.c
  group user_config
    ./user_config/: am_prj_config.h am_prj_config.c am_lpc82x_inst_init.h
    ./user_config/am_lpc82x_hwconfig/: am_lpc82x_hwconfig_adc0.c am_lpc82x_hwconfig_clk.c am_lpc82x_hwconfig_crc.c am_lpc82x_hwconfig_dma.c am_lpc82x_hwconfig_gpio.c am_lpc82x_hwconfig_i2c0.c am_lpc82x_hwconfig_i2c1.c am_lpc82x_hwconfig_i2c2.c am_lpc82x_hwconfig_i2c3.c am_lpc82x_hwconfig_int.c am_lpc82x_hwconfig_mrt.c am_lpc82x_hwconfig_sct0.c am_lpc82x_hwconfig_sct0_cap.c am_lpc82x_hwconfig_sct0_pwm.c am_lpc82x_hwconfig_sct0_timing.c am_lpc82x_hwconfig_spi0.c am_lpc82x_hwconfig_spi1.c am_lpc82x_hwconfig_systick.c am_lpc82x_hwconfig_usart0.c am_lpc82x_hwconfig_usart1.c am_lpc82x_hwconfig_usart2.c am_lpc82x_hwconfig_wkt.c am_lpc82x_hwconfig_wwdt.c
  group user_code
    ./user_code/: main.c am_temp.c am_temp_lm75.c
